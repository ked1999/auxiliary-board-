# Keil uVision project F407_auxiliary_board.uvprojx, settings and files
target F407_auxiliary_board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407_auxiliary_board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/tcsm;../BSP/tcsm/handler;../BSP/tcsm/driver;../Middlewares/log/Rtt;../Middlewares/log/easylogger/inc;../APP;../Core;../Middlewares/Big_Little_endian;../BSP/SV04M;../BSP/SV04M/handler;../BSP/SV04M/driver;../Middlewares/checksum;../BSP/SD1000;../BSP/SD1000/handler;../BSP/SD1000/driver;../BSP/sy_motor;../BSP/sy_motor/handler;../BSP/sy_motor/driver;../Middlewares/Modbus;../Middlewares/Chain_of_Responsibility;../BSP/task_control;../BSP/modbus_RTU;../BSP/sv04;..\BSP\jslz_onebus
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/: canfliter_init.c
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group APP
    ../APP/: app_task_control.c app_tcsm.c app_init.c app_sy_motor.c app_door.c app_probe.c
  group BSP/modbusrtu
    ../BSP/modbus_RTU/: modbus_rtu.c modbus_rtu_conifg.h modbus_rtu_protocol.c
  group BSP/TASK_CONTROL
    ../BSP/task_control/: task_control_sub.c
  group BSP/TCSM
    ../BSP/tcsm/: tcsm.c
    ../BSP/tcsm/handler/: tcsm_handler.c tcsm_config.h
    ../BSP/tcsm/driver/: tcsm_driver.c
  group BSP/SY
    ../BSP/sy_motor/: sy_motor.c
    ../BSP/sy_motor/driver/: sy_motor_driver.c
    ../BSP/sy_motor/handler/: sy_motor_config.h sy_motor_handler.c
  group BSP/SV04
    ../BSP/sv04/: sv04.c
  group BSP/one_bus
    ../BSP/jslz_onebus/: jslz_onebus.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/log
    ../Middlewares/log/Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Middlewares/log/easylogger/port/: elog_port.c
    ../Middlewares/log/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares/endian
    ../Middlewares/Big_Little_endian/: endian.c
  group Middlewares/checksum
    ../Middlewares/checksum/: checksum.c
  group Middlewares/modbusrtu
    ../Middlewares/Modbus/: mymodbus.c
  group Middlewares/chain_res
    ../Middlewares/Chain_of_Responsibility/: chain_sensor.c
software components: CMSIS:CORE 4.3.0
